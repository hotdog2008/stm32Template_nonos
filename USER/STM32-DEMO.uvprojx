# Keil uVision project STM32-DEMO.uvprojx, settings and files
target SPI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\stm32f1\CMSIS;..\USER;..\..\..\stm32f1\FWlib\inc;..\..\..\stm32f1\FWlib\src;..\..\..\stm32f1\eslib;..\..\..\stm32f1\FWlib;..\..\..\stm32f1\MAIN;..\..\..\stm32f1\OS\inc;..\..\..\stm32f1\ESExt;..\..\..\stm32f1\nnp5cpp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../../../stm32f1/CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: stm32f10x_it.c project.h stm32f10x_it.h config.h import.h project.cpp
  group CMSIS
    ../../../stm32f1/CMSIS/: core_cm3.c system_stm32f10x.c
  group ESLib
    ../../../stm32f1/ESLib/: es_iic.h es_encode.h es_bmp180.h mpu9150.h es_pwm.h es_nrf24.h es_gpio.h esapi.cpp esapi.h es_rtc.h es_flash.cpp es_flash.h QueObj.h U32Queue.h QueObj.cpp U32Queue.cpp Context.cpp Context.h MessageObj.h es_Timer.cpp es_Timer.h es_usart.cpp es_spi.cpp
  group FWLib
    ../../../stm32f1/FWlib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../../stm32f1/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../stm32f1/FWlib/: stm_std_lib.h
  group MAIN
    ../../../stm32f1/MAIN/: main.cpp es_board.h es_board.cpp
  group ESExt
    ../../../stm32f1/ESExt/: es_PC13_LED.cpp
  group nnp5
    ../../../stm32f1/nnp5cpp/src/: ACKPkg.cpp AT_Matcher.cpp DataRetrieval.cpp DRHandler.cpp FFMatcher.cpp MatcherBase.cpp pb_common.c pb_decode.c pb_encode.c ProtobufPkg.cpp RN_Matcher.cpp stream.cpp TransferredPKG.cpp TransportLayer.cpp
software components: CMSIS:CORE 4.3.0
